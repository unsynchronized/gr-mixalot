options:
  parameters:
    author: cstone@pobox.com
    category: Custom
    description: Example flowgraph for POCSAG transmitter
    generate_options: no_gui
    id: pocsagtx
    output_language: python
    run_options: run
  states: {}

blocks:
- name: capcode
  id: variable
  parameters:
    value: '1615132'
  states: {}
- name: max_deviation
  id: variable
  parameters:
    value: '4500.0'
  states: {}
- name: pagerfreq
  id: variable
  parameters:
    value: '931862500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: symrate
  id: variable
  parameters:
    value: '38400'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2.0 * math.pi * max_deviation / float(symrate)
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.7'
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: message
  id: parameter
  parameters:
    type: str
    value: '"GRAND CENTRAL\x0a\x0aHACK THE PLANET"'
  states: {}
- name: mixalot_pocencode_0
  id: mixalot_pocencode
  parameters:
    baudrate: int(1200)
    capcode: int(capcode)
    msg: str(message)
    symrate: int(symrate)
    type: '1'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: float(samp_rate)/float(symrate)
    type: ccf
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: ''
    center_freq0: pagerfreq
    clock_rate: '0.0'
    dev_addr: ''
    dev_args: '""'
    gain0: '0'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_char_to_float_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_multiply_const_vxx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [mixalot_pocencode_0, '0', blocks_char_to_float_0, '0']
- [pfb_arb_resampler_xxx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-70-gf44384ae
